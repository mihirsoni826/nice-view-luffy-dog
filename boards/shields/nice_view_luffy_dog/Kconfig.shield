## boards/shields/nice_view_luffy_dog/Kconfig.shield
```kconfig
config SHIELD_NICE_VIEW_LUFFY_DOG
    def_bool $(shields_list_contains,nice_view_luffy_dog)
```
